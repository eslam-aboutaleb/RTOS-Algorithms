# Keil uVision project OS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c GPIO_prog.c Led.c RCC_program.c SysTick.c GPIO_interface.h GPIO_private.h Led_interface.h Led_Port.h RCC_interface.h RCC_private.h SCB_interface.h SCB_private.h STD_TYPES.h SysTick_interface.h SysTick_private.h OS.h OS.c BIT_MATH.h NVIC.c NVIC_interface.h NVIC_private.h OS.s Tasks.c Tasks.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
