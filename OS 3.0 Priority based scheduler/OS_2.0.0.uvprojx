# Keil uVision project OS_2.0.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS_2.0.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: BIT_MATH.h GPIO_interface.h GPIO_private.h Led_interface.h Led_Port.h NVIC_interface.h NVIC_private.h RCC_interface.h RCC_private.h SCB_interface.h SCB_private.h STD_TYPES.h SysTick_interface.h SysTick_private.h Tasks.h Timer_interface.h Timer_private.h GPIO_prog.c Led.c main.c NVIC.c RCC_program.c SysTick.c Tasks.c Timer_program.c
  group OS
    ./: OS.c OS_FIFO_Buffer.c OS_Mailbox.c OS_Services.c OS.s OS.h OS_FIFO_Buffer.h OS_Mailbox.h OS_Services.h Semaphore.h Semaphore.c OS_Portable.c OS_Portable.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
